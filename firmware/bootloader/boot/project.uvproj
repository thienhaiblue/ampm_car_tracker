# Keil uVision project project.uvproj, settings and files
target Bootloader (ARM-ADS)
  device: STM32F103CB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: mototracker_boot +hex
  AfterMake: fromelf --bin --output .\Flash\mototracker_boot.bin .\Flash\mototracker_boot.axf
  c flags: Optim=1
  c define: STM32F10X_MD
  c include: ..\Drivers;..\Libraries\CMSIS\CM3\CoreSupport;..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\Drivers\my_driver;..\Drivers\STM32F10x_StdPeriph_Driver\src;..\Drivers\STM32F10x_StdPeriph_Driver\inc;.\Src;..\Libraries\common_lib\acclerometer;..\Libraries\common_lib\flash_mem;..\Libraries\common_lib\gps;..\Libraries\common_lib\ringbuff;..\Libraries\common_lib\usb;..\Libraries\common_lib\gsm_modem;..\Libraries\common_lib\sys_time
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Startup
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group Drivers
    ../Drivers/STM32F10x_StdPeriph_Driver/src/: stm32f10x_flash.c
    ../Drivers/my_driver/: spi.c
  group Main
    ./Src/: main.c FlashProg.c
  group USB
    ../Libraries/common_lib/usb/: hiduser.c usbcore.c usbdesc.c usbhw.c usbuser.c
  group FlashMem
    ../Libraries/common_lib/flash_mem/: sst25.c
