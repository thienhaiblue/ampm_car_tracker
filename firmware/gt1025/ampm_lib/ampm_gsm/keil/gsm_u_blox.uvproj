# Keil uVision project gsm_u_blox.uvproj, settings and files
target GSM-U-BLOX (ARM-ADS)
  device: STM32F101RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: ampm_gsm (library)
  c flags: Optim=1
  c include: ..\..\..\ampm_lib;..\..\gsm;..\..\common
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group GSM
    ../: at_command_parser.c ampm_gsm_call.c ampm_gsm_common.c ampm_gsm_dial_up.c ampm_gsm_io.c ampm_gsm_main_task.c ampm_gsm_ring.c ampm_gsm_sms.c ampm_gsm_startup.c
    ../sms/: pdu.c
